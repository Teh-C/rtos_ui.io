# Keil uVision project demo.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\INCLUDE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\BSP\ADC;..\BSP\BEEP;..\BSP\FLASH;..\BSP\KEY;..\BSP\SYSTICK;..\BSP\TIMER;..\BSP\TIMESTAMP;..\BSP\USART;..\DEVICE;..\DRIVER;..\USER;..\CORE;..\BSP\LED;..\FreeRTOS\user;..\DRIVER;..\DEVICE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group BSP
    ../BSP/SYSTICK/: bsp_systick.c
    ../BSP/USART/: bsp_usart1.c
    ../BSP/FLASH/: bsp_flash.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/BEEP/: bsp_beep.c
    ../BSP/ADC/: bsp_adc1.c
    ../BSP/LED/: bsp_led.h bsp_led.c
    ../BSP/TIMER/: bsp_timer3.c bsp_timer4.c
  group DRIVER
    ../DRIVER/: ILI9341_drv.c
  group DEVICE
    ../DEVICE/: lcd_dev.c
  group USER
    ../USER/: main.c includes.h FreeRTOSConfig.h
  group FREERTOS/SOURCE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOS/PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FREERTOS/USER
    ../FreeRTOS/user/: SysInfoTool.c
